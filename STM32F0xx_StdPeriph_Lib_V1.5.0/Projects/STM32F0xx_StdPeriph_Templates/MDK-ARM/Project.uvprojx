# Keil uVision project Project.uvprojx, settings and files
target STM32F051 (ARM-ADS)
  device: STM32F051K8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F051
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F051,USE_STM320518_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s startup_stm32f042.s startup_stm32f031.s startup_stm32f070xb.s startup_stm32f091.s startup_stm32f070x6.s startup_stm32f030xc.s startup_stm32f072.s startup_stm32f051.s
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group User
    ../: main.c stm32f0xx_it.c
    ./LOAD/User/: iwtdg.c rcc_configure.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_pwr.c stm32f0xx_exti.c stm32f0xx_syscfg.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_flash.c stm32f0xx_iwdg.c stm32f0xx_adc.c stm32f0xx_rcc.c stm32f0xx_dma.c stm32f0xx_rtc.c stm32f0xx_gpio.c stm32f0xx_dbgmcu.c stm32f0xx_crc.c stm32f0xx_wwdg.c stm32f0xx_can.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_crs.c stm32f0xx_comp.c stm32f0xx_dac.c stm32f0xx_cec.c
  group SYSTEM
    ./LOAD/SYSTEM/: delay.c serial_port.c
    ./LOAD/SYSTEM/cmd/: CMD_Receive.c
    ./LOAD/SYSTEM/fifo/: fifo.c store_fifo.c
  group HARDWARE
    ./LOAD/HARDWARE/: hardware.c Motor_pwm.c
  group APP
    ./LOAD/APP/: app.c comm_task.c common.c i2c.c key_power_on_task.c send_data_to_phone.c
  group OS
    ./LOAD/OS/: os_core.c
  group MODULE
    ./LOAD/MODULE/: protocol_module.c
target STM32F031 (ARM-ADS)
  device: STM32F031K6 STMicroelectronics
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F031
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F031,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
target STM32F072 (ARM-ADS)
  device: STM32F072VB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F072
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072,USE_STM32072B_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32072B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
target STM32F030 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  cpu: as above
  output: STM32F030
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
target STM32F042 (ARM-ADS)
  device: STM32F042T6 STMicroelectronics
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F042
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F042,SE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --diag_suppress=L6329
target STM32F091 (ARM-ADS)
  device: STM32F091VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F091
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F091,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
target STM32F030xC (ARM-ADS)
  device: STM32F030RC STMicroelectronics
  cpu: as above
  output: STM32F030xC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030xC,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
target STM32F070x6 (ARM-ADS)
  device: STM32F070C6 STMicroelectronics
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: STM32F070x6
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F070x6,SE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
target STM32F070xB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F070CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F070xB +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F070xB,USE_DEFAULT_TIMEOUT_CALLBACK
  c misc: --c99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc;..\..\..\Libraries\CMSIS\Include;.\LOAD\SYSTEM;.\LOAD\HARDWARE;.\LOAD\APP;.\LOAD\OS;.\LOAD\MODULE;.\LOAD\CORE;.\LOAD\SYSTEM\cmd;.\LOAD\SYSTEM\fifo;.\LOAD\User;..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
